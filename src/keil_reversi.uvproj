# Keil uVision project keil_reversi.uvproj, settings and files
target Simulator (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2105 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: keil_reversi
  c flags: Optim=4 oTime=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Startup Code
    ./: Startup.s
  group System Calls
    ./: Retarget.c
  group Source Code
    ./: main.c Power_management.c Power_management.h boton_eints.c boton_eints.h timers.c timers.h event_queue.c event_queue.h gpio.c gpio.h logical_shifts.s eventos.c eventos.h Gestion_pulsacion.c Gestion_pulsacion.h reversi8.c reversi8.h led.c led.h rtc.c rtc.h watchdog.c watchdog.h SWI.s sys_calls.h uart0.c uart0.h sc.c sc.h interprete.c interprete.h
